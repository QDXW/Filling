# Keil uVision project Laminating.uvprojx, settings and files
target Laminating (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Laminating
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Source\Modules\adc;.\Source\Modules\Common;.\Source\Modules\CRC16;.\Source\Modules\DMA;.\Source\Modules\HostComm;.\Source\Modules\HostProcess;.\Source\Modules\Temp;.\Source\FWLib\inc;.\Source\CORE;.\Source\ISR;.\Source\System;.\Source\Modules\Devices;.\Source\Modules\Sensor;.\Source\Modules\Laminating;.\Source\Modules\Flash;.\Source\Modules\Movement;.\Source\Modules\Comm;.\Source\Modules\TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ./Source/CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ./Source/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_can.c
  group ISR
    ./Source/ISR/: stm32f10x_it.c
  group System
    ./Source/System/: system_stm32f10x.c main.c Global_variable.c
  group Modules
    ./Source/Modules/Laminating/: Laminating.c
    ./Source/Modules/Common/: Common.c
    ./Source/Modules/adc/: adc.c
    ./Source/Modules/DMA/: dma.c
    ./Source/Modules/Temp/: Temp.c TempControl.c
    ./Source/Modules/Devices/: devices.c Device_Action.c
    ./Source/Modules/Sensor/: sensor.c
    ./Source/Modules/Movement/: Movement.c
    ./Source/Modules/Flash/: Flash.c
    ./Source/Modules/CRC16/: CRC16.c
    ./Source/Modules/HostComm/: HostComm.c
    ./Source/Modules/HostProcess/: HostProcess.c
    ./Source/Modules/Comm/: Comm.c Comm_CAN.c Comm_CAN_FIFO.c
    ./Source/Modules/TIMER/: Timer4.c
